# IAR project LC_sensor_metering.ewp, settings and files
configuration LC_sensor_metering (ARM, debug)
  General.OGChipSelectEditMenu: STM32L476RG ST STM32L476RG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L476xx; USE_STM32L4XX_NUCLEO
  ICCARM.CCIncludePath2: ../Inc; ..\..\..\Libraries\STM32L4xx_Driver\STM32L4xx_HAL_Driver\Inc; ..\..\..\Libraries\STM32L4xx_Driver\STM32L4xx_HAL_Driver\Inc\Legacy; ..\..\..\Libraries\STM32L4xx_Driver\CMSIS\Include; ..\..\..\Libraries\STM32L4xx_Driver\CMSIS\Device\ST\STM32L4xx\Include; ..\..\..\Libraries\STM32L4xx_Driver\BSP\STM32L4xx_Nucleo
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: LC_sensor_metering.hex
  ILINK.IlinkOutputFile: LC_sensor_metering.out
  ILINK.IlinkIcfFile: stm32l476xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../../../Libraries/STM32L4xx_Driver/CMSIS/Device/ST/STM32L4xx/Source/Templates/iar/: startup_stm32l476xx.s
  group Application/User
    ../Src/: lc_sensor_metering.c main.c stm32l4xx_hal_msp.c stm32l4xx_it.c
  group Drivers/BSP/STM32L4xx_Nucleo
    ../../../Libraries/STM32L4xx_Driver/BSP/STM32L4xx_Nucleo/: stm32l4xx_nucleo.c
  group Drivers/CMSIS
    ../../../Libraries/STM32L4xx_Driver/CMSIS/Device/ST/STM32L4xx/Source/Templates/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../Libraries/STM32L4xx_Driver/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_comp.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dac.c stm32l4xx_hal_dac_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_lptim.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c
