<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\LC_sensor_metering.ewp</path>
  </project>
  <batchBuild />
</workspace>
